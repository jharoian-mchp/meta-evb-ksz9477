COMPATIBLE_MACHINE = "(sama5d3-eds-sd)"

