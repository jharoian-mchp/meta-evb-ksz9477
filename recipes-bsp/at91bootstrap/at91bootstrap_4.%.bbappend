COMPATIBLE_MACHINE = "(sama5d3-eds-sd)"

AT91BOOTSTRAP_CONFIG:sama5d3-eds-sd ??= "${AT91BOOTSTRAP_MACHINE}sd_uboot"

AT91BOOTSTRAP_LOAD:sama5d3-eds-sd ??= "sdboot-uboot"
